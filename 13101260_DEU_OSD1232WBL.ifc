Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c3b40de3-c8e4-4462-8590-dcfee4609112, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-02T07:24:23+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13101260_DEU_OSD1232WBL:331B3DSW_DEU_13101260_OSD1232WBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW, z_Miele_Design_CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 331B3DSW_DEU_13101260_OSD1232WBL; sets with these values: 2
